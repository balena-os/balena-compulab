SRCBRANCH = "imx_4.14.98_2.0.0_ga"
SRCREV = "d32727a9d7ef2543729c149a713db24b8f5c2aa8"
