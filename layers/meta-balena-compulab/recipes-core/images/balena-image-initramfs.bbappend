IMAGE_ROOTFS_MAXSIZE = "40960"

do_image_create_sdcard_symlink() {
	echo "Do nothing";
}
