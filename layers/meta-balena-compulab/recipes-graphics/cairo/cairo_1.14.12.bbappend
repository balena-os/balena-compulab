# remove dependency to egl and glesv2
PACKAGECONFIG[egl] = ""
PACKAGECONFIG[glesv2] = ""
