SRC_URI = "git://github.com/intel/${BPN};nobranch=1"
