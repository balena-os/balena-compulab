include resin-image.inc

RESIN_BOOT_PARTITION_FILES_append_cl-som-imx8 = " \
    imx-boot-cl-som-imx8-sd.bin-flash_evk:\
"
