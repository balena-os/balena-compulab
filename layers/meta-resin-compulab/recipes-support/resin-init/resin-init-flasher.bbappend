INTERNAL_DEVICE_KERNEL_cl-som-imx8 = "mmcblk0"
